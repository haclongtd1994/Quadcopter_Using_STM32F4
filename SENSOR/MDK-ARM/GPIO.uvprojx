# Keil uVision project GPIO.uvprojx, settings and files
target GPIO (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL
  c include: ..\..\SENSOR;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c stm32f4xx_it.c delay_using_systick.c pwm_output.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_tim.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
